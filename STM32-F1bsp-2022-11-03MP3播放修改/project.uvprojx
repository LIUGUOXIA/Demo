# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: .\BSP;.\BSP\inc;.\library\CMSIS\startup;.\library\CMSIS;.\library\STM32F1xx_StdPeriph_Driver\inc;.\user;.\library\STD_Library\STD_LIB;.\__config;.\user\FATFS;.\user\flash;.\user\vs1053;.\BSP\ADS8688
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_conf.h stm32f10x_it.c
  group BSP
    ./BSP/: bsp.c
    ./BSP/src/: bsp_timer.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_key.c bsp_led.c bsp_soft_pwmled.c bsp_beep.c bsp_irda.c bsp_adc.c bsp_ap3216c.c bsp_i2c.c
  group StdPeriph_Driver
    ./library/STM32F1xx_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./library/CMSIS/: system_stm32f10x.c
    ./library/CMSIS/startup/: startup_stm32f10x_hd.s
  group STD_Library
    ./library/STD_Library/STD_LIB/: STD_Lib.c
  group vs1053
    ./user/vs1053/: VS1053.c
  group flash
    ./user/flash/: bsp_spi_flash.c
  group FATFS
    ./user/FATFS/: diskio.c ff.c
    ./user/FATFS/option/: cc936.c
  group ADS8688
    ./BSP/ADS8688/: bsp_ads8688.c
